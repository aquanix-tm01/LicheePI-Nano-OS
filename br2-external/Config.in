## br2-external/package/myapp/Config.in
```kconfig
config BR2_PACKAGE_MYAPP
	bool "myapp"
	depends on BR2_TOOLCHAIN_HAS_THREADS
	help
	  LVGL application (fbdev + evdev).
```
